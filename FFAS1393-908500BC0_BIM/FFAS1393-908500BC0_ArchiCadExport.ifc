Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-30T11:19:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.60.25 - Exporter 21.1.60.25 - Alternate UI 21.1.60.25
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 11:19:44 2023 * Host: CHATPONG-DEE * Database: C:\Users\CHATPONG\AppData\Local\Temp\33ca801e-a51f-49a0-bfac-93a2148b4abb\ff82f2b7-49d4-4fe7-824f-c720559bfb12\ifc * Database version: 5507 * Database creation date: Thu Mar 30 11:19:43 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 11:19:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 11:19:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: FFAS1393-908500BC0_REVIT:Acacia E Towel Rack, FFAS1393-908500BC0_REVIT:Acacia E Towel Rack:349620
In: Level 1
Type - Material: Brass, Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Acacia E Towel Rack
Material: Chrome
Pset_DistributionFlowElementCommon - Reference: Acacia E Towel Rack; sets with these values: 2
